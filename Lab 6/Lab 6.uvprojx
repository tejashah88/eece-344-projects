# Keil uVision project Lab 6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab 6
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./lib/systick/: SysTick.c
    ./lib/pll/: PLL.c
    ./lib/lcd/: lcd_driver.c
    ./lib/timing_util/: timing.c
    ./lib/adc/: adc_temp.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
